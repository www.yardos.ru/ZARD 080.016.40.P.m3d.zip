# KOMPAS-3D part (ZARD 080.016.40.P.m3d)

Model tree:
1. Булева операция:1
2. Булева операция:2

Texts:
  ЗАРД 080.016.40-ХХ.Р
  ООО "ИК Энерпред-Ярдос"